<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\01-LedBlink.ewp</path>
  </project>
  <batchBuild />
</workspace>
