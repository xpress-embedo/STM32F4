# IAR project LVGL_Sample.ewp, settings and files
configuration LVGL_Sample (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; LV_CONF_INCLUDE_SIMPLE
  ICCARM.CCIncludePath2: ../Core/Inc; C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Inc; C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/CMSIS/Device/ST/STM32F4xx/Include; C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/CMSIS/Include; ..\; ..\lvgl; ..\hal_stm_lvgl; ..\hal_stm_lvgl\tft; ..\hal_stm_lvgl\touchpad; ..\hal_stm_lvgl; ..\hal_stm_lvgl\tft; ..\hal_stm_lvgl\touchpad
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LVGL_Sample.hex
  ILINK.IlinkOutputFile: LVGL_Sample.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c rgb_mixer.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/HAL_STM_LVGL
    ../hal_stm_lvgl/: stm32f429i_discovery.c stm32f429i_discovery.h
  group Drivers/HAL_STM_LVGL/tft
    ../hal_stm_lvgl/tft/: ili9341.c ili9341.h tft.c tft.h
  group Drivers/HAL_STM_LVGL/touchpad
    ../hal_stm_lvgl/touchpad/: stmpe811.c stmpe811.h touchpad.c touchpad.h
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/xpress_embedo/STM32Cube/Repository/STM32Cube_FW_F4_V1.27.1/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group lvgl
    ../lvgl/: lv_conf.h lvgl.h
  group lvgl/examples
    ../lvgl/examples/: lv_examples.h
  group lvgl/examples/get_started
    ../lvgl/examples/get_started/: lv_example_get_started.h lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c
  group lvgl/examples/widgets/btn
    ../lvgl/examples/widgets/btn/: lv_example_btn_1.c
  group lvgl/examples/widgets/labels
    ../lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c lv_example_label_5.c
  group lvgl/src
    ../lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/src/core
    ../lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/src/draw
    ../lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/src/draw/arm2d
    ../lvgl/src/draw/arm2d/: lv_gpu_arm2d.c lv_gpu_arm2d.h
  group lvgl/src/draw/gd32_ipa
    ../lvgl/src/draw/gd32_ipa/: lv_gpu_gd32_ipa.c lv_gpu_gd32_ipa.h
  group lvgl/src/draw/stm32_dma2d
    ../lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/src/draw/sw
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/src/draw/swm341_dma2d
    ../lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c lv_gpu_swm341_dma2d.h
  group lvgl/src/font
    ../lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/src/hal
    ../lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/src/layouts/flex
    ../lvgl/src/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/src/layouts/grid
    ../lvgl/src/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/src/libs/bmp
    ../lvgl/src/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/src/libs/ffmpeg
    ../lvgl/src/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/src/libs/freetype
    ../lvgl/src/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/src/libs/fsdrv
    ../lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/src/libs/gif
    ../lvgl/src/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/src/libs/png
    ../lvgl/src/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/src/libs/qrcode
    ../lvgl/src/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
  group lvgl/src/libs/rlottie
    ../lvgl/src/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/src/libs/sjpg
    ../lvgl/src/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/src/libs/tiny_ttf
    ../lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
  group lvgl/src/misc
    ../lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_malloc_builtin.c lv_malloc_builtin.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_memcpy_builtin.c lv_memcpy_builtin.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/src/others/file_explorer
    ../lvgl/src/others/file_explorer/: lv_file_explorer.c lv_file_explorer.h
  group lvgl/src/others/fragment
    ../lvgl/src/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c
  group lvgl/src/others/gridnav
    ../lvgl/src/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/src/others/ime
    ../lvgl/src/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h
  group lvgl/src/others/imgfont
    ../lvgl/src/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/src/others/monkey
    ../lvgl/src/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/src/others/msg
    ../lvgl/src/others/msg/: lv_msg.c lv_msg.h
  group lvgl/src/others/snapshot
    ../lvgl/src/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/src/themes
    ../lvgl/src/themes/: lv_themes.h
  group lvgl/src/themes/basic
    ../lvgl/src/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/src/themes/default
    ../lvgl/src/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/src/themes/mono
    ../lvgl/src/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/src/widgets/animimg
    ../lvgl/src/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/src/widgets/arc
    ../lvgl/src/widgets/arc/: lv_arc.c lv_arc.h
  group lvgl/src/widgets/bar
    ../lvgl/src/widgets/bar/: lv_bar.c lv_bar.h
  group lvgl/src/widgets/btn
    ../lvgl/src/widgets/btn/: lv_btn.c lv_btn.h
  group lvgl/src/widgets/btnmatrix
    ../lvgl/src/widgets/btnmatrix/: lv_btnmatrix.c lv_btnmatrix.h
  group lvgl/src/widgets/calendar
    ../lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/src/widgets/canvas
    ../lvgl/src/widgets/canvas/: lv_canvas.c lv_canvas.h
  group lvgl/src/widgets/chart
    ../lvgl/src/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/src/widgets/checkbox
    ../lvgl/src/widgets/checkbox/: lv_checkbox.c lv_checkbox.h
  group lvgl/src/widgets/colorwheel
    ../lvgl/src/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/src/widgets/dropdown
    ../lvgl/src/widgets/dropdown/: lv_dropdown.c lv_dropdown.h
  group lvgl/src/widgets/img
    ../lvgl/src/widgets/img/: lv_img.c lv_img.h
  group lvgl/src/widgets/imgbtn
    ../lvgl/src/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/src/widgets/keyboard
    ../lvgl/src/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
  group lvgl/src/widgets/label
    ../lvgl/src/widgets/label/: lv_label.c lv_label.h
  group lvgl/src/widgets/led
    ../lvgl/src/widgets/led/: lv_led.c lv_led.h
  group lvgl/src/widgets/line
    ../lvgl/src/widgets/line/: lv_line.c lv_line.h
  group lvgl/src/widgets/list
    ../lvgl/src/widgets/list/: lv_list.c lv_list.h
  group lvgl/src/widgets/menu
    ../lvgl/src/widgets/menu/: lv_menu.c lv_menu.h
  group lvgl/src/widgets/meter
    ../lvgl/src/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/src/widgets/msgbox
    ../lvgl/src/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/src/widgets/objx_templ
    ../lvgl/src/widgets/objx_templ/: lv_objx_templ.c lv_objx_templ.h
  group lvgl/src/widgets/roller
    ../lvgl/src/widgets/roller/: lv_roller.c lv_roller.h
  group lvgl/src/widgets/slider
    ../lvgl/src/widgets/slider/: lv_slider.c lv_slider.h
  group lvgl/src/widgets/span
    ../lvgl/src/widgets/span/: lv_span.c lv_span.h
  group lvgl/src/widgets/spinbox
    ../lvgl/src/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/src/widgets/spinner
    ../lvgl/src/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/src/widgets/switch
    ../lvgl/src/widgets/switch/: lv_switch.c lv_switch.h
  group lvgl/src/widgets/table
    ../lvgl/src/widgets/table/: lv_table.c lv_table.h
  group lvgl/src/widgets/tableview
    ../lvgl/src/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/src/widgets/textarea
    ../lvgl/src/widgets/textarea/: lv_textarea.c lv_textarea.h
  group lvgl/src/widgets/titleview
    ../lvgl/src/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/src/widgets/win
    ../lvgl/src/widgets/win/: lv_win.c lv_win.h
